# Keil uVision project Project.uvprojx, settings and files
target Wireless Sensor (6120000::V6.12::.\ARMCLANG)
  device: STM32F031F6Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=2
  c define: NDEBUG, SWD_DISABLED
  c misc: -Wno-extra-semi-stmt -Wno-sign-conversion -Wno-implicit-int-conversion -Wno-conditional-uninitialized -Wno-missing-prototypes
  c include: ..\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ../../src/: adc.c bmp180.c control.c main.c
  group inc
    ../../inc/: flash.h gpio.h i2c.h nrf24l01.h si7021.h spi.h tim.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0

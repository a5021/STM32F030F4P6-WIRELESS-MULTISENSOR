# IAR project wireless sensor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F031F6 ST STM32F031F6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F031x6
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\drivers; ..\..\drivers\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wireless sensor.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkExtraOptions: --log call_graph
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F031x6; SWD_DISABLED
  ICCARM.CCIncludePath2: inc; drivers; drivers\inc
  ICCARM.IccLang: 2
  group (top)
    ../../: main.c
  group drivers/inc
    drivers/: core_cm0.h core_cmFunc.h core_cmInstr.h system_stm32f0xx.h
    ../../drivers/inc/: stm32f0xx.h
  group drivers/src
    ../../drivers/src/: startup_stm32f031x6.s system_stm32f0xx.c
  group inc
    ../../inc/: adc.h bh1750.h bmp180.h control.h flash.h gpio.h i2c.h nrf24l01.h si7021.h spi.h tim.h usart.h
  group src
    ../../src/: adc.c bmp180.c control.c
